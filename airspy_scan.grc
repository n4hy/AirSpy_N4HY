options:
  parameters:
    author: n4hy
    description: Swept spectrum scanner for AirSpy R2. Each dwell's FFT is painted onto one fixed frequency axis running ALF (left) to AHF (right), in decimal MHz, with a fixed dB scale. Controls along the bottom.
    generate_options: qt_gui
    id: airspy_scan
    output_language: python
    title: AirSpy Scanner (ALF - AHF)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: AirSpy R2 supports ONLY 10e6 and 2.5e6 sps. No other value is legal.
    value: 10e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    comment: FFT bins per 10 MHz slice. Must match the stitcher vlen default.
    value: '1024'
  states: {}
- name: nbins
  id: variable
  parameters:
    comment: Bins across the whole ALF..AHF axis. Must match stitcher nbins default.
    value: '4096'
  states: {}
- name: frame_rate
  id: variable
  parameters:
    comment: logpwrfft frames/s. At 0.2 s dwell this gives ~10 frames per slice.
    value: '50'
  states: {}
- name: ymin_db
  id: variable
  parameters:
    comment: Bottom of the graph. Also the level unswept bins sit at, so the trace starts flat along the bottom instead of spiking to a floor.
    value: '-120'
  states: {}
- name: ymax_db
  id: variable
  parameters:
    comment: Top of the graph.
    value: '0'
  states: {}
- name: overlap
  id: variable
  parameters:
    comment: Step = overlap * samp_rate. <1.0 overlaps slices so the analog filter roll-off at the slice edges does not leave gaps.
    value: '0.8'
  states: {}
- name: alf_readout
  id: variable_qtgui_label
  parameters:
    gui_hint: 8,0,1,2
    label: ALF   scan LOW frequency
    type: string
    value: '''%.3f MHz'' % min(alf_mhz, ahf_mhz)'
  states: {}
- name: ahf_readout
  id: variable_qtgui_label
  parameters:
    gui_hint: 8,2,1,2
    label: AHF   scan HIGH frequency
    type: string
    value: '''%.3f MHz'' % max(alf_mhz, ahf_mhz)'
  states: {}
- name: alf_mhz
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,0,1,2
    label: ALF  -  scan LOW frequency (MHz)
    min_len: '250'
    start: '24.0'
    step: '0.1'
    stop: '1800.0'
    value: '24.0'
  states: {}
- name: ahf_mhz
  id: variable_qtgui_range
  parameters:
    gui_hint: 9,2,1,2
    label: AHF  -  scan HIGH frequency (MHz)
    min_len: '250'
    start: '24.0'
    step: '0.1'
    stop: '1800.0'
    value: '1800.0'
  states: {}
- name: dwell_s
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,0,1,2
    label: Dwell per slice (s)
    min_len: '250'
    start: '0.02'
    step: '0.01'
    stop: '2.0'
    value: '0.2'
  states: {}
- name: sweep_en
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 10,2,1,2
    label: Sweep running (uncheck to hold)
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,0,1,1
    label: LNA gain (dB)
    min_len: '150'
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '12'
  states: {}
- name: mix_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,1,1,1
    label: MIX gain (dB)
    min_len: '150'
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '12'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,2,1,1
    label: VGA gain (dB)
    min_len: '150'
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '10'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: '""'
    args: '"airspy=0"'
    bb_gain0: vga_gain
    freq0: 24e6 + samp_rate/2
    gain0: lna_gain
    gain_mode0: 'False'
    if_gain0: mix_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_size
    frame_rate: frame_rate
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: stitcher
  id: epy_block
  parameters:
    alf_hz: min(alf_mhz, ahf_mhz) * 1e6
    ahf_hz: max(alf_mhz, ahf_mhz) * 1e6
    floor_db: ymin_db
    nbins: nbins
    samp_rate: samp_rate
    settle: '2'
    vlen: fft_size
    _source_code: |
      """Paint each dwell's FFT onto a fixed ALF..AHF frequency axis.

      The radio sees only samp_rate Hz at a time, so a graph spanning
      ALF..AHF is painted one dwell at a time. Each logpwrfft frame arrives
      fftshifted (shift=True on the FFT block), so its bin 0 is
      centre - samp_rate/2; those bins are written to their true position in
      a fixed nbins-wide vector whose index 0 is ALF and index nbins-1 AHF.

      Bins are never dropped to a deep floor. An earlier version cleared each
      slice to -160 dB on retune, which drew vertical spikes down off the
      graph wherever a slice had not yet been painted or was mid-refresh.
      Instead the vector starts at floor_db (the bottom of the graph, so the
      opening trace is flat along the axis) and each dwell OVERWRITES its own
      bins on its first accepted frame, then max-holds within that dwell.
      A bin therefore always carries the most recent measurement of that
      frequency and never falls through the floor of the plot.

      Frames captured while the tuner is still settling would carry the old
      slice's energy under the new centre label, placing signals at
      frequencies where they are not, so `settle` frames are discarded after
      every retune.
      """

      import threading

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Scan Painter: dwell FFTs -> fixed ALF..AHF axis"""

          def __init__(self, vlen=1024, nbins=4096, alf_hz=24e6,
                       ahf_hz=1800e6, samp_rate=10e6, settle=2,
                       floor_db=-120.0):
              gr.sync_block.__init__(
                  self,
                  name='Scan Painter',
                  in_sig=[(np.float32, vlen)],
                  out_sig=[(np.float32, nbins)],
              )
              self.vlen = int(vlen)
              self.nbins = int(nbins)
              self.samp_rate = float(samp_rate)
              self.settle = int(settle)
              self._floor = float(floor_db)
              self._lock = threading.Lock()
              self._alf = float(alf_hz)
              self._ahf = float(ahf_hz)
              self._center = None
              self._pending = None
              self._skip = 0
              self._fresh = False
              self._spec = np.full(self.nbins, self._floor, dtype=np.float32)

          def set_center(self, fc):
              """Called from the sweep thread each time the LO moves."""
              with self._lock:
                  self._pending = float(fc)

          @property
          def floor_db(self):
              return self._floor

          @floor_db.setter
          def floor_db(self, value):
              with self._lock:
                  self._floor = float(value)

          @property
          def alf_hz(self):
              return self._alf

          @alf_hz.setter
          def alf_hz(self, value):
              with self._lock:
                  self._alf = float(value)
                  self._spec[:] = self._floor

          @property
          def ahf_hz(self):
              return self._ahf

          @ahf_hz.setter
          def ahf_hz(self, value):
              with self._lock:
                  self._ahf = float(value)
                  self._spec[:] = self._floor

          def _slice_bins(self, fc, lo, step):
              """Global bin index for each of this slice's vlen FFT bins."""
              binw = self.samp_rate / self.vlen
              f = fc - self.samp_rate / 2.0 + np.arange(self.vlen) * binw
              g = np.floor((f - lo) / step).astype(np.int64)
              ok = (g >= 0) & (g < self.nbins)
              return g, ok

          def work(self, input_items, output_items):
              out = output_items[0]
              with self._lock:
                  lo = min(self._alf, self._ahf)
                  hi = max(self._alf, self._ahf)
                  step = (hi - lo) / self.nbins if self.nbins else 0.0
                  for frame in input_items[0]:
                      if self._pending is not None:
                          self._center = self._pending
                          self._pending = None
                          self._skip = self.settle
                          self._fresh = True
                      if self._skip > 0:
                          self._skip -= 1
                      elif self._center is not None and step > 0.0:
                          g, ok = self._slice_bins(self._center, lo, step)
                          if ok.any():
                              gi, vi = g[ok], frame[ok]
                              if self._fresh:
                                  # First frame of this dwell: refresh the slice
                                  # so the bins show the newest measurement.
                                  # Many FFT bins land on one display bin (~43
                                  # of them at 10 MSPS across the full range),
                                  # so gi holds duplicates. A fancy-index
                                  # assignment would be last-wins and would
                                  # erase a peak with whatever bin was written
                                  # last; reduce with maximum.at instead.
                                  self._spec[gi] = self._floor
                                  self._fresh = False
                              np.maximum.at(self._spec, gi, vi)
                  np.maximum(self._spec, self._floor, out=self._spec)
                  out[:] = self._spec
              return len(out)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 0,0,8,4
    legend: 'False'
    update_time: '0.05'
    vlen: nbins
    x_axis_label: '"Frequency"'
    x_start: min(alf_mhz, ahf_mhz)
    x_step: (max(alf_mhz, ahf_mhz) - min(alf_mhz, ahf_mhz)) / nbins
    x_units: '"MHz"'
    y_axis_label: '"Power"'
    y_units: '"dB"'
    ymax: ymax_db
    ymin: ymin_db
  states: {}
- name: layout_fix
  id: snippet
  parameters:
    section: main_after_init
    code: |
      self._qtgui_vector_sink_f_0_win.setMinimumSize(900, 550)
      self.resize(1600, 1000)
  states: {}
- name: sweep_start
  id: snippet
  parameters:
    section: main_after_start
    code: |
      import math
      import threading

      # AirSpy R2 tuning limits, as reported by the device itself
      # (SoapySDRUtil --probe="driver=airspy": Full freq range [24, 1800] MHz).
      _F_MIN = 24e6
      _F_MAX = 1800e6

      def _plan(tb):
          """Centre frequencies covering [ALF, AHF], recomputed every hop so
          that moving the ALF/AHF sliders takes effect immediately."""
          lo_mhz, hi_mhz = sorted((float(tb.alf_mhz), float(tb.ahf_mhz)))
          sr = float(tb.samp_rate)
          lo = max(lo_mhz * 1e6, _F_MIN)
          hi = min(hi_mhz * 1e6, _F_MAX)
          if hi - lo <= sr:
              return [0.5 * (lo + hi)]
          stepsz = max(sr * float(tb.overlap), 1.0)
          n = int(math.ceil((hi - lo - sr) / stepsz)) + 1
          return [min(lo + sr / 2.0 + k * stepsz, hi - sr / 2.0)
                  for k in range(n)]

      def _sweeper(tb):
          idx = 0
          while not tb._sweep_stop.is_set():
              if int(tb.sweep_en) == 0:
                  tb._sweep_stop.wait(0.1)
                  continue
              centers = _plan(tb)
              fc = centers[idx % len(centers)]
              idx += 1
              tb.osmosdr_source_0.set_center_freq(fc, 0)
              tb.stitcher.set_center(fc)
              tb._sweep_stop.wait(max(float(tb.dwell_s), 0.02))

      self._sweep_stop = threading.Event()
      self._sweep_thread = threading.Thread(target=_sweeper, args=(self,))
      self._sweep_thread.daemon = True
      self._sweep_thread.start()
  states: {}
- name: sweep_stop
  id: snippet
  parameters:
    section: main_after_stop
    code: |
      try:
          self._sweep_stop.set()
          self._sweep_thread.join(timeout=2.0)
      except AttributeError:
          pass
  states: {}

connections:
- [osmosdr_source_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', stitcher, '0']
- [stitcher, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
